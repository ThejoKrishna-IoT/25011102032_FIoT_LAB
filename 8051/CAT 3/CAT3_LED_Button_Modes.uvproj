# Keil uVision project CAT3_LED_Button_Modes.uvproj, settings and files
target AT89S52 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0x1FFF) CLOCK(11059200)
  output: firmware +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STARTUP.A51
