# Keil uVision project TASK7A.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(11059200) MODP2
  output: TASK_7A +hex
  group Source Group 1
    ./: STARTUP.A51 lcd.c keypad.c main.c
